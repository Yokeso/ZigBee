<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Smart_home.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>Smart_home</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>Smart_home</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>Smart_home</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


